# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\24c02;.\App\iic;.\App\key;.\App\smg;.\App\ds1302
  group User
    ./User/: main.c
  group App
    ./App/24c02/: 24c02.c
    ./App/iic/: iic.c
    ./App/smg/: smg.c
    ./App/key/: key.c
    ./App/ds1302/: ds1302.c
  group Public
    ./Public/: public.c
